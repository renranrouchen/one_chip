# Keil uVision project LD3320.uvproj, settings and files
target LD3320 (MCS-51)
  device: STC10F12XE STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(45000000) MODP2
  output: V07B +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\user
  group USER
    ./USER/: main.c usart.c Reg.c LD3320.c
