# Keil uVision project 程序.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 程序 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\LED;..\HARDWARE\ENCODER;..\HARDWARE\MOTOR;..\HARDWARE\TIMER;..\HARDWARE\CC2541;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\BEEP;..\HARDWARE\MAX30102;..\HARDWARE\KEY;..\HARDWARE\LCD1602;..\HARDWARE\DS18B20;..\HARDWARE\GPIO;..\HARDWARE\ADC_DMA;..\HARDWARE\OLED_4PIN;..\HARDWARE\usart;..\HARDWARE\MOTO_STEP;..\HARDWARE\FLASH;..\HARDWARE\DS1302;..\HARDWARE\DHT11;..\HARDWARE\SR04;..\HARDWARE\USART2;..\HARDWARE\HX711;..\HARDWARE\DEMO;..\HARDWARE\MAX30102EX
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/DEMO/: My_Demo.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_dbgmcu.c stm32f10x_adc.c stm32f10x_flash.c
